# Keil uVision project libduer-device.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: libduer-device (library)
  c flags: Optim=3 OneElfS=1
  c define: __KEIL_MDK__ __LPB100__ DUER_DEBUG_LEVEL=3 __TARGET_TRACKER__
  c misc: --diag_suppress=494  --c99  -DMBEDTLS_CONFIG_FILE=\"baidu_ca_mbedtls_config.h\"
  c include: ..\..\..\..\LPB100-HSF-V1.51\sdk\1.51\include;..\..\..\external\baidu_json;..\..\..\external\mbed-client-c\nsdl-c;..\..\..\external\mbed-client-c-port;..\..\..\external\mbed-client-c\source\libCoap\src\include;..\..\..\external\mbed-client-c\source\libNsdl\src\include;..\..\..\external\mbed-trace;..\..\..\external\mbedtls\include;..\..\..\external\mbedtls-port;..\..\..\framework\core;..\..\..\framework\include;..\..\..\framework\utils;..\..\..\modules\coap;..\..\..\modules\connagent;..\..\..\platform\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group libduer-device
    ../../../external/baidu_json/: baidu_json.c
    ../../../external/mbed-client-c/source/libCoap/src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    ../../../external/mbed-client-c/source/libNsdl/src/: sn_grs.c sn_nsdl.c
    ../../../framework/core/: lightduer_debug.c lightduer_memory.c lightduer_mutex.c lightduer_net_trans_aes_cbc_encrypted.c lightduer_net_trans_encrypted.c lightduer_net_transport.c lightduer_net_transport_wrapper.c lightduer_random.c lightduer_sleep.c lightduer_thread.c lightduer_timestamp.c
    ../../../framework/utils/: lightduer_aes.c lightduer_hashcode.c lightduer_net_util.c lightduer_queue_cache.c
    ../../../modules/coap/: lightduer_coap.c lightduer_coap_ep.c lightduer_coap_trace.c lightduer_nsdl_adapter.c
    ../../../modules/connagent/: lightduer_ca.c lightduer_ca_conf.c lightduer_connagent.c lightduer_engine.c
    ../../../platform/source-lpb100/: baidu_ca_adapter.c baidu_ca_debug_adp.c baidu_ca_memory_adp.c baidu_ca_mutex_adp.c baidu_ca_socket_adp.c lightduer_events.c lightduer_priority_conf.c lightduer_timers.c
    ../../../external/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../external/mbed-client-c-port/: ns_list.c
